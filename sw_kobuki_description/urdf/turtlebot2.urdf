Commit message: Feature: kobuki ros2 gazebo

File: sw_kobuki_description/urdf/turtlebot2.urdf (robot description, URDF)
Before this commit: robot turtlebot, 36 links, 35 joints
Links:
- link gyro_link: mass 0.001 -> None
